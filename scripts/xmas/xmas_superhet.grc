options:
  parameters:
    author: QEMU scripts/xmas
    comment: 'The receiver half of the XMAS transmitter: two sine waves, a mixer and an FM detector, running at an offset so the modulation survives and the sample rate does not. See README.md in this directory.'
    copyright: 'SPDX-License-Identifier: GPL-2.0-or-later'
    description: Superheterodyne receiver for the emulated XMAS FM transmitter
    generate_options: no_gui
    id: xmas_superhet_grc
    output_language: python
    run_options: run
    title: XMAS superhet receiver
  states: {}

blocks:
- name: rf_dump
  id: parameter
  parameters:
    comment: The file -M pic16-devboard,rf-dump= wrote.
    label: RF dump
    type: str
    value: rf.txt
  states: {}
- name: out_wav
  id: parameter
  parameters:
    comment: Where the demodulated audio goes.
    label: Output WAV
    type: str
    value: radio.wav
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    comment: The movie's audio rate; every decimation is keyed to it.
    label: Audio rate (Hz)
    type: intx
    value: '22050'
  states: {}
- name: deviation
  id: parameter
  parameters:
    comment: Peak deviation the transmitter was set to.
    label: Deviation (Hz)
    type: intx
    value: '75000'
  states: {}
- name: carrier
  id: parameter
  parameters:
    comment: Carrier the transmitter was tuned to; 0 to take the resting frequency from the dump instead.
    label: Carrier (Hz)
    type: intx
    value: '98000000'
  states: {}
- name: plan
  id: variable
  parameters:
    comment: 'Where the receiver puts everything: the IF, the LO, the difference product and the three rates, all chosen from the audio rate and the deviation so every decimation is a whole number and the baseband clears Carson''s rule.'
    value: xmas_superhet.Plan(audio_rate, deviation)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: plan.samp_rate
  states: {}
- name: import_blocks
  id: import
  parameters:
    imports: import xmas_rf_blocks
  states: {}
- name: import_superhet
  id: import
  parameters:
    imports: import xmas_superhet
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: nco_if_source
  id: epy_block
  parameters:
    comment: 'The transmitter''s instantaneous IF, in hertz, at the graph''s rate. Every increment carries the virtual time it was written at, so the stream keeps the firmware''s own timing: an interrupt that ran late, or a queue that ran dry and held the last increment, is in the audio exactly as it would be on air.'
    _source_code: |
      # The block itself lives in xmas_rf_blocks.py so that the driver
      # and this flowgraph share one copy of it.
      from xmas_rf_blocks import nco_if_source

      blk = nco_if_source
    rf_dump: rf_dump
    samp_rate: samp_rate
    carrier_hz: carrier
    if_sim_hz: plan.if_hz
  states: {}
- name: blocks_vco_f
  id: blocks_vco_f
  parameters:
    amplitude: '1.0'
    comment: The IF sine. Sensitivity 2*pi turns an input in hertz into that many hertz of output.
    samp_rate: samp_rate
    sensitivity: 2*math.pi
  states: {}
- name: analog_sig_source_x
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    comment: The local oscillator. On the board this is the ADF4002 near 108 MHz; here it is the same number shifted down with the IF, so the difference between them is untouched.
    freq: plan.lo_hz
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx
  id: blocks_multiply_xx
  parameters:
    comment: The mixer.
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: plan.rf_hz
    comment: Takes the mixer's difference product and throws away the sum an octave up, and brings what is left down to a complex baseband the detector can read.
    decim: plan.bb_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, plan.guard*1.1, plan.guard*0.5)
    type: fcf
  states: {}
- name: analog_quadrature_demod_cf
  id: analog_quadrature_demod_cf
  parameters:
    comment: The FM detector. This gain turns angle per sample into hertz.
    gain: plan.bb_rate/(2*math.pi)
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Hertz to full scale, and negative: the board injects on the high side, so its output is carrier - k*audio and the spectrum comes back inverted. A real receiver inverts it back too.'
    const: '-1.0/deviation'
    type: float
  states: {}
- name: fir_filter_xxx
  id: fir_filter_xxx
  parameters:
    comment: Down to the audio rate.
    decim: plan.audio_decim
    taps: firdes.low_pass(1.0, plan.bb_rate, audio_rate*0.45, audio_rate*0.15)
    type: fff
  states: {}
- name: deemph
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0 - plan.deemph_alpha
    comment: '75 us de-emphasis, the receiver''s half of the broadcast standard: a single real pole at the alpha of the master''s pre-emphasis.'
    order: '1'
    type: ff
  states: {}
- name: deemph_gain
  id: blocks_multiply_const_vxx
  parameters:
    comment: single_pole_iir is (1-alpha)/(1-alpha*z^-1); dividing the (1-alpha) back out leaves the exact inverse of the master's filter, so the cascade is unity and the recording sits at the movie's own level.
    const: 1.0/(1.0 - plan.deemph_alpha)
    type: float
  states: {}
- name: blocks_wavfile_sink
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: out_wav
    format: FORMAT_WAV
    samp_rate: audio_rate
  states: {}

connections:
- [nco_if_source, '0', blocks_vco_f, '0']
- [blocks_vco_f, '0', blocks_multiply_xx, '0']
- [analog_sig_source_x, '0', blocks_multiply_xx, '1']
- [blocks_multiply_xx, '0', freq_xlating_fir_filter_xxx, '0']
- [freq_xlating_fir_filter_xxx, '0', analog_quadrature_demod_cf, '0']
- [analog_quadrature_demod_cf, '0', blocks_multiply_const_vxx, '0']
- [blocks_multiply_const_vxx, '0', fir_filter_xxx, '0']
- [fir_filter_xxx, '0', deemph, '0']
- [deemph, '0', deemph_gain, '0']
- [deemph_gain, '0', blocks_wavfile_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
